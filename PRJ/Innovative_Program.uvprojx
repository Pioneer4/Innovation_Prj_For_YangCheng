# Keil uVision project Innovative_Program.uvprojx, settings and files
target Innovative_Program (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Innovative_Program +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\DEVICE;..\LIB\inc;..\SYSTEM;..\UCOS-II\CONFIG;..\UCOS-II\CORE;..\UCOS-II\PORT;..\USER;..\DEVICE\LCD;..\PROTOCOL;..\DEVICE\TOUCH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: stm32f4xx_it.c main.c
  group DEVICE
    ../DEVICE/: key.c infraded.c led.c iwdg.c esp8266_uart.c esp8266.c w25qxx.c dht11.C motor.c spi.c savedata.C C02.c
    ../DEVICE/LCD/: lcd.c
    ../DEVICE/TOUCH/: touch.c
  group SYSTEM
    ../SYSTEM/: sys.c uart.c delay.c adc.c
  group LIB
    ../LIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_adc.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group PROTOCOL
    ../PROTOCOL/: HTTP_Demo.c
  group UCOSII-CORE
    ../UCOS-II/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOS-II/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOS-II/CONFIG/: includes.h os_cfg.h
